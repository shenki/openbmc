KBRANCH ?= "dev-6.12"
LINUX_VERSION ?= "6.12.9"

SRCREV="03ff31ad54522521755b55609eaad19db05ddf46"

require linux-aspeed.inc
