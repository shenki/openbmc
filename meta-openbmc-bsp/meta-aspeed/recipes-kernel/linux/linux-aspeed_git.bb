KBRANCH ?= "dev-4.17"
LINUX_VERSION ?= "4.17"

SRCREV="0961f4d09f74ca7cb12b46406cdca2d50f857336"

require linux-aspeed.inc
