SRCREV ?= "0a2c6c1edc4746e13ba6de454dee81ec37f9fd72"
SKELETON_URI ?= "git://github.com/shenki/skeleton;branch=flasher-cleanups"
