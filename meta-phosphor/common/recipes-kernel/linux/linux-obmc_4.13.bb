KBRANCH ?= "drm-v1"
LINUX_VERSION ?= "4.13.16"

SRCREV="9680ed7979d5d403c6bde36271a048d62c048180"

require linux-obmc.inc
